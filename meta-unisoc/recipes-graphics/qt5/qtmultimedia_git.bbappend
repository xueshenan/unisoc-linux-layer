PACKAGECONFIG_append += " \
                    gstreamer \
"
