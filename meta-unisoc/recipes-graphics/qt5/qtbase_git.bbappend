PACKAGECONFIG += "gles2 tslib evdev libinput udev accessibility xkb xkbcommon"
