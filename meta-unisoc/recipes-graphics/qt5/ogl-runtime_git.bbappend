FILESEXTRAPATHS_append := "${THISDIR}/files"

SRC_URI += " \
            file://cancel_3ds_example.diff \
           "
