FILESEXTRAPATHS_append := "${THISDIR}/files"

SRC_URI += " \
            file://cancel_qt3d_example.diff \
           "
