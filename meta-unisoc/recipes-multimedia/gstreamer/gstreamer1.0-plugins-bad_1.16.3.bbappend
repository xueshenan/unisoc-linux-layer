
PACKAGECONFIG_append ="faac"