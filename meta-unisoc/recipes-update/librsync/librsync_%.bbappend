EXTRA_OECMAKE += "-DBUILD_RDIFF=ON"
DEPENDS += "popt"
BBCLASSEXTEND += "native"
