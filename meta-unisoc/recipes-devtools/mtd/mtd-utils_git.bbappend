FILESEXTRAPATHS_append := "${THISDIR}/${PN}:${THISDIR}/${PN}/default:${THISDIR}/files"
#SRC_URI += " \
#           file://mkubifs-scandir-sort-dir-file-for-ota.patch \
#"
