FILESEXTRAPATHS_prepend := "${THISDIR}/files/${MACHINE}:"

#SRC_URI = "file://config file://${MACHI/machconfig"


